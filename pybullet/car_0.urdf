Commit message: add debug tools

File: pybullet/car_0.urdf (robot description, URDF)
Before this commit: robot car, 1 links, 0 joints
Links:
- link base_link: mass 10.0 -> None
